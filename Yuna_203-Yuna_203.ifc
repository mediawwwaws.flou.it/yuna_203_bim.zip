Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 0ea773d0-2009-484e-aa4b-a328cf7efe8f, VersionGUID: 5f528c8f-f617-4374-b4a5-5a332d1caee6, NumberOfSaves: 2]
File name: Yuna_203-Yuna_203.ifc
Time: 2025-10-24T09:29:45+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (ITA) - IFC 25.4.0.27

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Pset_SiteCommon - Reference: Informazioni sul progetto
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - Reference: Informazioni sul progetto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informazioni sul progetto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informazioni sul progetto; sets with these values: 2
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello (2)
Pset_BuildingStoreyCommon - Reference: Livello
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Quote - Altezza di calcolo: 0 m
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Livello
Name | LongName = Nome | Elevation (m) = Quota altimetrica (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurniture: Yuna_203:Yuna_203, Yuna_203:Yuna_203:139679
In: 0 - Piano Terra
Type - Material: <Unnamed>
Type - Altro - Categoria: Arredi; Nome famiglia: Yuna_203
Type - Vincoli - Prospetto di default: 0 m
Type - Quote - Altezza: 0 m
Type - Dati identità - Nome del tipo: Yuna_203
Pset_EnvironmentalImpactIndicators - Reference: Yuna_203; sets with these values: 2
Altro - Famiglia: Yuna_203; Famiglia e tipo: Yuna_203: Yuna_203; ID tipo: 139654; Tipo: Yuna_203
Vincoli - Host: Muro di base : Generico - 30 cm; Livello: 0 - Piano Terra; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Sposta con gli elementi più vicini: no
Quote - Area: 15.2659 m2; Volume: 1.36718 m3
Fasi - Fase di creazione: Stato di Progetto
